Commit message: Update robot1.urdf

File: urdf/robot1.urdf (robot description, URDF)
Before this commit: robot robot1, 6 links, 5 joints
Joints:
- joint base_wheel_left_joint: axis (none) -> 0 1 0
